# Keil uVision project class_project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: class_project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c DS18B20.c DS18B20.h lcd.c lcd.h password.c password.h show_temp.c show_temp.h clock.c clock.h delay.h delay.c
